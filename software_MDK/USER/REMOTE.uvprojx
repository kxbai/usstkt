# Keil uVision project REMOTE.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: REMOTE +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\REMOTE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\oledlib;..\HARDWARE\BEEP;..\HARDWARE\LCD;..\Watch;..\HARDWARE;..\HARDWARE\mpu;..\HARDWARE\mpu\eMPL;..\MYAPP;..\HARDWARE\DA17
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/: i2c_soft.c ADC.c DS3231.c bme280.c
    ../HARDWARE/DA17/: DA17.c myiic.c
  group mpu6050
    ../HARDWARE/mpu/: mpu_task.c mpu6050.c
    ../HARDWARE/mpu/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c dma.c
    ./: NVIC.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_pwr.c stm32f10x_exti.c
  group README
    ../: README.TXT
  group watch
    ../Watch/: alarm.c alarms.c animation.c appconfig.c buttons.c diag.c display.c draw.c game1.c game2.c game3.c games.c global.c m_display.c m_main.c menu.c millis.c normal.c resources.c settings.c sleep.c sound.c stopwatch.c time.c timedate.c torch.c tune.c tunemaker.c tunes.c ui.c pwrmgr.c
  group oledlib
    ../HARDWARE/oledlib/: oled_basic.c oled_bmp.c oled_buffer.c oled_color.c oled_config.c oled_debug.c oled_draw.c oled_draw_ex_example.c oled_driver.c oled_font.c test.c
  group MyApp
    ../MYAPP/: gui_log_console.c gui_log_console.h My_Menu.c My_Menu.h altitude_display.c altitude_display.h
